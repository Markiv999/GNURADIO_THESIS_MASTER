options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '250000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {state: disabled}
- name: blocks_exponentiate_const_cci_0_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {state: disabled}
- name: blocks_exponentiate_const_cci_0_1
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock1
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock2
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock3
    type: complex
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock4
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 0.00157079632679489661923132169164 *4
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0.00157079632679489661923132169164 *2 *4 '
  states: {state: disabled}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 0.00157079632679489661923132169164 *4 *4
  states: {}
- name: blocks_rotator_cc_0_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 0.00157079632679489661923132169164*8 *4
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1250'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_file_sink_0_1, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_exponentiate_const_cci_0, '0', blocks_exponentiate_const_cci_0_0, '0']
- [blocks_exponentiate_const_cci_0, '0', blocks_file_sink_0_1, '0']
- [blocks_exponentiate_const_cci_0_0, '0', blocks_exponentiate_const_cci_0_1, '0']
- [blocks_exponentiate_const_cci_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0_2, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_rotator_cc_0, '0', blocks_file_sink_0_2, '0']
- [blocks_rotator_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_rotator_cc_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_rotator_cc_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_rotator_cc_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_rotator_cc_0_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_rotator_cc_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
