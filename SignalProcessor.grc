options:
  parameters:
    generate_options: qt_gui
    id: SignalProcessor
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\presentationsignal
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock2
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock3
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock4
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1875000'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1000000, 500000, 250000, 125000)
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vectorsize=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64,np.complex64,np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.vectorsize = vectorsize
              self.j=0
              self.signal1=[]
              self.signal2=[]
              self.signal3=[]
              self.signal4=[]

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              signal1temp = input_items[0]
              signal2temp = input_items[1]
              signal3temp = input_items[2]
              signal4temp = input_items[3]
              num_samples = input_items.shape[0]
              for k in range(num_samples):
                  self.signal1.append[signal1temp]
                  self.signal2.append[signal2temp]
                  self.signal3.append[signal3temp]
                  self.signal4.append[signal4temp]
                  self.j+=num_samples
                  if self.j>10000:
                      break
                  
              finalsignal=        




              return len(output_items[0])
    vectorsize: '1.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1875000'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', epy_block_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_file_source_0_0, '0', epy_block_0, '1']
- [blocks_file_source_0_1, '0', blocks_stream_mux_0, '2']
- [blocks_file_source_0_1, '0', epy_block_0, '2']
- [blocks_file_source_0_2, '0', blocks_stream_mux_0, '3']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_mux_0, '0', blocks_head_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_mux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
