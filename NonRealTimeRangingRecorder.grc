options:
  parameters:
    generate_options: qt_gui
    id: NonRealTimeRangingRecorder
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: variable_qtgui_chooser_1
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: '145000000'
    option1: '435000000'
    type: int
    value: '145000000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\RangingSignals\75KLengthSignal\Through5
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\RangingSignals\75KLengthSignal\Switchtest16
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\FinalSignal4
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 75000*5
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '700000000'
    fc: '145000000'
    fftsize: '32768'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '1'
    size: '1875000'
    srate: samp_rate
    style1: '0'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: variable_qtgui_chooser_1
    clock_source0: gpsdo
    gain0: '60'
    samp_rate: samp_rate
    sync: gps_time
    time_source0: gpsdo
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: variable_qtgui_chooser_1
    clock_source0: gpsdo
    gain0: '50'
    samp_rate: samp_rate
    sync: gps_time
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_agc_xx_0, '0', blocks_file_sink_0_0, '0']
- [analog_agc_xx_0, '0', blocks_head_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
