options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '100'
    value: '0.1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: variable_qtgui_range_0
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '20000'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\FinalSignal4
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '187500'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import scipy as scipy

      class CorrelationDelayEstimator(gr.decim_block):
          def __init__(self, vectorsize=18750, sample_rate=500000, max_delay=1000):
              gr.decim_block.__init__(
                  self,
                  name='CorrelationDelayEstimator',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.float32],
                  decim=vectorsize
              )
              self.set_relative_rate(1.0/vectorsize)
              self.decimation = vectorsize
              self.vectorsize = vectorsize
              self.range_clock_signal = np.zeros(vectorsize, dtype=np.complex64)
              self.sequential_signal = np.zeros(vectorsize, dtype=np.complex64)
              self.i = 0
              self.j = 0
              self.counter = 0
              self.sample_rate = sample_rate
              self.correlation_values = np.zeros(vectorsize, dtype=np.complex64)
              self.max_delay=max_delay

          def work(self, input_items, output_items):
              sequential_signal = input_items[0]
              range_clock_signal = input_items[1]
              num_samples = sequential_signal.shape[0]
              n=1
              # Process each sample in the input buffer
              for k in range(num_samples):
                  if self.i < self.vectorsize/n:
                      # Take the latest values from the buffer
                      self.range_clock_signal[self.i] = range_clock_signal[k]
                      self.sequential_signal[self.i] = sequential_signal[k]
                      self.i += 1
                  else:
                      # Calculate delay
                      #self.range_clock_signal=self.range_clock_signal[0 : self.vectorsize/n]
                      #self.sequential_signal = self.sequential_signal[0 : self.vectorsize/n]
                      self.correlation_values = np.fft.ifft(np.fft.fft(self.range_clock_signal) * np.conj(np.fft.fft(self.sequential_signal)))
                      #self.correlation_values= scipy.signal.correlate(self.range_clock_signal, self.sequential_signal, mode='full', method='auto')
                      self.sample_delay_count = np.argmax(np.abs(self.correlation_values))
                     # self.sample_delay_count=np.argmax(np.correlate(self.range_clock_signal,self.sequential_signal))
                      delay = self.vectorsize - self.sample_delay_count
                      delay_in_micro_seconds = 10 ** 6 * delay / self.sample_rate
                      #correlationfactor=self.correlation_values[self.sample_delay_count]/np.sum(np.abs(self.correlation_values))
                      output_items[0][0] = delay
                      #n=n*2
                      #if n==16:
                      #    n=1
                      self.i = 0
              self.j = 0
              return num_samples // self.vectorsize
    max_delay: '1000'
    sample_rate: samp_rate
    vectorsize: '187500'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '187500'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', epy_block_1_0_0_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_head_0, '0']
- [blocks_throttle2_0, '0', epy_block_1_0_0_0, '0']
- [epy_block_1_0_0_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
