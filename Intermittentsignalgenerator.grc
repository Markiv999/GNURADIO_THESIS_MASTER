options:
  parameters:
    generate_options: qt_gui
    id: Intermittentsignalgenerator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\Sequential Ranging Signal\Clock6intermittent
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '500000'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 1.2566370614359172953850573533118 /4
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (250000, 250000)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_mux_0, '1']
- [analog_const_source_x_0_0, '0', blocks_throttle2_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0_1, '0']
- [blocks_rotator_cc_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_stream_mux_0, '0', blocks_head_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
