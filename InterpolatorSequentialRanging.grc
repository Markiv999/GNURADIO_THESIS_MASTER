options:
  parameters:
    author: LocalAdmin
    generate_options: qt_gui
    id: InterpolatorSequentialRanging
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Interpolation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: lowPassTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate_interpolated/(Interpolation*2)
    gain: '1.0'
    samp_rate: samp_rate_interpolated
    width: samp_rate_interpolated/(Interpolation*4)
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_interpolated
  id: variable
  parameters:
    value: samp_rate*Interpolation
  states: {}
- name: vectorsize
  id: variable
  parameters:
    value: 1875000*5
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURadioThesisReportData\SentSignalInterpolated1
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURadioThesisReportData\ReceviedSignalInterpolated1
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: D:\GNURadioThesisReportData\SentSignal1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: D:\GNURadioThesisReportData\ReceviedSignal1
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_head_3_0
  id: blocks_head
  parameters:
    num_items: vectorsize
    type: complex
  states: {}
- name: blocks_head_3_0_0
  id: blocks_head
  parameters:
    num_items: vectorsize
    type: complex
  states: {}
- name: blocks_head_3_0_1
  id: blocks_head
  parameters:
    num_items: vectorsize*Interpolation
    type: complex
  states: {}
- name: blocks_head_3_0_1_1
  id: blocks_head
  parameters:
    num_items: vectorsize*Interpolation
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Interpolation
    taps: lowPassTaps
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Interpolation
    taps: lowPassTaps
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_head_3_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_head_3_0_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [blocks_head_3_0_1, '0', blocks_file_sink_0_0_0, '0']
- [blocks_head_3_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_3_0_1_1, '0', blocks_file_sink_0_0, '0']
- [blocks_head_3_0_1_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle2_0, '0', blocks_head_3_0, '0']
- [blocks_throttle2_0_0, '0', blocks_head_3_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_head_3_0_1_1, '0']
- [interp_fir_filter_xxx_0_0_0, '0', blocks_head_3_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
