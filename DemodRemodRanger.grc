options:
  parameters:
    generate_options: qt_gui
    id: DemodRemodRanger
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.0005'
    stop: '10'
    value: '0.00'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: sps_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1000'
    value: '300'
  states: {state: disabled}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '15000'
    value: '50'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: variable_qtgui_range_0
    type: byte
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: variable_qtgui_range_0
    type: complex
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '5'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_1_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x0B ,0xF1 ,0xC4 ,0x1A ,0x17 ,0x17 ,0x3E ,0x51 ,0x2C ,0x93 ,0x0F ,0xD0 ,0x2C ,0x43 ,0x84 ,0xB0 ,0xDF ,0x04 ,0x4A ,0x99 ,0x26 ,0x0B ,0xDE ,0x92 ,0xAB ,0xC7 ,0x69 ,0x15)
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
  states: {state: disabled}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import scipy as scipy

      class CorrelationDelayEstimator(gr.decim_block):
          def __init__(self, vectorsize=18750, sample_rate=500000, max_delay=1000):
              gr.decim_block.__init__(
                  self,
                  name='CorrelationDelayEstimator',
                  in_sig=[np.ubyte, np.ubyte],
                  out_sig=[np.float32],
                  decim=vectorsize
              )
              self.set_relative_rate(1.0/vectorsize)
              self.decimation = vectorsize
              self.vectorsize = vectorsize
              self.range_clock_signal = np.zeros(vectorsize, dtype=np.ubyte)
              self.sequential_signal = np.zeros(vectorsize, dtype=np.ubyte)
              self.i = 0
              self.j = 0
              self.counter = 0
              self.sample_rate = sample_rate
              self.correlation_values = np.zeros(vectorsize, dtype=np.ubyte)
              self.max_delay=max_delay

          def work(self, input_items, output_items):
              sequential_signal = input_items[0]
              range_clock_signal = input_items[1]
              num_samples = sequential_signal.shape[0]
              n=1
              # Process each sample in the input buffer
              for k in range(num_samples):
                  if self.i < self.vectorsize/n:
                      # Take the latest values from the buffer
                      self.range_clock_signal[self.i] = range_clock_signal[k]
                      self.sequential_signal[self.i] = sequential_signal[k]
                      self.i += 1
                  else:
                      # Calculate delay
                      #self.range_clock_signal=self.range_clock_signal[0 : self.vectorsize/n]
                      #self.sequential_signal = self.sequential_signal[0 : self.vectorsize/n]
                      self.correlation_values = np.fft.ifft(np.fft.fft(self.range_clock_signal) * np.conj(np.fft.fft(self.sequential_signal)))
                      #self.correlation_values= scipy.signal.correlate(self.range_clock_signal, self.sequential_signal, mode='full', method='auto')
                      self.sample_delay_count = np.argmax(np.abs(self.correlation_values))
                     # self.sample_delay_count=np.argmax(np.correlate(self.range_clock_signal,self.sequential_signal))
                      delay = self.vectorsize - self.sample_delay_count
                      delay_in_micro_seconds = 10 ** 6 * delay / self.sample_rate
                      #correlationfactor=self.correlation_values[self.sample_delay_count]/np.sum(np.abs(self.correlation_values))
                      output_items[0][0] = delay
                      #n=n*2
                      #if n==16:
                      #    n=1
                      self.i = 0
              self.j = 0
              return num_samples // self.vectorsize
    max_delay: '1000'
    sample_rate: samp_rate
    vectorsize: 28*8
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 10240*2
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: 10240*2
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: 28*8
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    type: fff
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(145e6, 5e6)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '"type=b200"'
    gain0: '50'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: gps_time
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(145e6, 5e6)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '"type=b200"'
    gain0: '60'
    otw: sc16
    samp_rate: samp_rate
    sync: gps_time
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_gmsk_demod_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '1']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_delay_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_delay_0_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_1_0_0_0, '1']
- [blocks_float_to_uchar_0_0, '0', epy_block_1_0_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_gfsk_mod_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_gmsk_mod_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_throttle2_0, '0', blocks_unpack_k_bits_bb_1_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_uchar_to_float_1, '0', rational_resampler_xxx_0, '0']
- [blocks_uchar_to_float_1_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_unpack_k_bits_bb_1_1, '0', blocks_delay_0, '0']
- [blocks_unpack_k_bits_bb_1_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1_1, '0', blocks_uchar_to_float_0_0_0, '0']
- [blocks_unpack_k_bits_bb_1_1, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_throttle2_0, '0']
- [digital_gfsk_mod_0, '0', blocks_delay_0_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_const_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_gmsk_demod_0, '0', blocks_null_sink_0, '0']
- [digital_gmsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gmsk_demod_0, '0', blocks_uchar_to_float_1, '0']
- [digital_gmsk_mod_0, '0', qtgui_const_sink_x_0, '0']
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [epy_block_1_0_0_0, '0', qtgui_number_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_uchar_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_float_to_uchar_0_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
