options:
  parameters:
    generate_options: qt_gui
    id: demodRemod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/bitrate)
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\CorrelationwithDelfiBoard\remoddedsignal
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: D:\GNURADIO_THESIS_MASTER\CorrelationwithDelfiBoard\ReceivedSignals
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: sps
    sensitivity: 2*3.14/sps
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
  states: {}

connections:
- [blocks_file_source_1, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', digital_gmsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_gmsk_demod_0, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
