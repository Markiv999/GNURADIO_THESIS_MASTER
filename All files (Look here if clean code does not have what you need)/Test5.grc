options:
  parameters:
    generate_options: qt_gui
    id: Test5
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Temporary\Temporary2\Transmitter.xlsb
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Temporary\Temporary2\Receiver.xlsb
    repeat: 'True'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class CorrelationDelayEstimator(gr.sync_block):
          def __init__(self, vectorsize=18750, sample_rate=500000):
              gr.sync_block.__init__(
                  self,
                  name='CorrelationDelayEstimator',
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32]
              )
              self.vectorsize = vectorsize
              self.range_clock_signal = np.zeros(vectorsize, dtype=np.complex64)
              self.sequential_signal = np.zeros(vectorsize, dtype=np.complex64)
              self.i = 0
              self.j = 0
              self.sample_rate = sample_rate
              self.correlation_values = np.zeros(vectorsize, dtype=np.complex64)

          def work(self, input_items, output_items):
              sequential_signal = input_items[0][:]
              range_clock_signal = input_items[1][:]
              num_samples = sequential_signal.shape[0]
              #print(num_samples)
              
             #while there are still values in the buffer
              while self.j < num_samples:
                  if self.i < self.vectorsize:
                      #Take the latest values from the buffer
                      self.range_clock_signal[self.i] = range_clock_signal[self.j]
                      self.sequential_signal[self.i] = sequential_signal[self.j]
                      output_items[0][self.j] = 0
                      self.i += 1
                      self.j += 1            
                      continue

                  # calculate delay, then return to the while loop
                  self.correlation_values = np.fft.ifft(np.fft.fft(self.range_clock_signal) * np.conj(np.fft.fft(self.sequential_signal)))
                  self.sample_delay_count = np.argmax(np.abs(self.correlation_values))
                  delay = self.vectorsize - self.sample_delay_count
                  delay_in_micro_seconds = 10 ** 6 * delay / self.sample_rate

                  output_items[0][self.j] = delay_in_micro_seconds
                  self.i = 0
                  print(delay)

              self.j = 0
              return num_samples
    sample_rate: samp_rate
    vectorsize: '1400'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0_0, '0', epy_block_1, '1']
- [blocks_file_source_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle_0, '0', epy_block_1, '0']
- [epy_block_1, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
